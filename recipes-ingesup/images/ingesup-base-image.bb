DESCRIPTION = "IOT image minimal, to get the hardware running"

inherit ingesup-base-image
